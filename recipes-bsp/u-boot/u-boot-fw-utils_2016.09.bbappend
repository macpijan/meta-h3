FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-uboot-armbian-banana-patches.patch \
           file://0002-change-BPIm2plus-dtb-file-name.patch"
